Commit message: WIP

File: drake/examples/kuka_iiwa_arm/models/objects/heavy_box.urdf (robot description, URDF)
Before this commit: robot simple_cuboid, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.2 0.2 0.199; visual box size=0.2 0.2 0.2
